# Keil uVision project STM32F373C8_CurveTracer.uvproj, settings and files
target STM32F373C8_CurveTracer (ARM-ADS)
  device: STM32F373C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F373C8_CurveTracer +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F37X, USE_STDPERIPH_DRIVER
  c include: ..\STM32F37x_DSP_StdPeriph_Lib_V1.1.0\Libraries\CMSIS\Device\ST\STM32F37x\Include;..\STM32F37x_DSP_StdPeriph_Lib_V1.1.0\Libraries\CMSIS\Device\ST\STM32F37x\Source\Templates;..\STM32F37x_DSP_StdPeriph_Lib_V1.1.0\Libraries\STM32F37x_StdPeriph_Driver\inc;.\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ./: startup_stm32f373xc.s
  group SRC
    ./src/: main.c stm32f37x_it.c
  group CMSIS
    ../STM32F37x_DSP_StdPeriph_Lib_V1.1.0/Libraries/CMSIS/Device/ST/STM32F37x/Source/Templates/: system_stm32f37x.c
  group Std_Periph_Lib
    ../STM32F37x_DSP_StdPeriph_Lib_V1.1.0/Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_cec.c stm32f37x_comp.c stm32f37x_crc.c stm32f37x_dac.c stm32f37x_dbgmcu.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_iwdg.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_wwdg.c
